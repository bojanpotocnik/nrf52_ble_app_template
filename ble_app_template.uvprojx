# Keil uVision project ble_app_template.uvprojx, settings and files
target nrf52840_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  AfterMake: version\delete_version_object.bat
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=6 S140 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: nRF5_SDK_15\components;nRF5_SDK_15\components\ble\ble_advertising;nRF5_SDK_15\components\ble\ble_dtm;nRF5_SDK_15\components\ble\ble_racp;nRF5_SDK_15\components\ble\ble_services\ble_ancs_c;nRF5_SDK_15\components\ble\ble_services\ble_ans_c;nRF5_SDK_15\components\ble\ble_services\ble_bas;nRF5_SDK_15\components\ble\ble_services\ble_bas_c;nRF5_SDK_15\components\ble\ble_services\ble_cscs;nRF5_SDK_15\components\ble\ble_services\ble_cts_c;nRF5_SDK_15\components\ble\ble_services\ble_dfu;nRF5_SDK_15\components\ble\ble_services\ble_dis;nRF5_SDK_15\components\ble\ble_services\ble_gls;nRF5_SDK_15\components\ble\ble_services\ble_hids;nRF5_SDK_15\components\ble\ble_services\ble_hrs;nRF5_SDK_15\components\ble\ble_services\ble_hrs_c;nRF5_SDK_15\components\ble\ble_services\ble_hts;nRF5_SDK_15\components\ble\ble_services\ble_ias;nRF5_SDK_15\components\ble\ble_services\ble_ias_c;nRF5_SDK_15\components\ble\ble_services\ble_lbs;nRF5_SDK_15\components\ble\ble_services\ble_lbs_c;nRF5_SDK_15\components\ble\ble_services\ble_lls;nRF5_SDK_15\components\ble\ble_services\ble_nus;nRF5_SDK_15\components\ble\ble_services\ble_nus_c;nRF5_SDK_15\components\ble\ble_services\ble_rscs;nRF5_SDK_15\components\ble\ble_services\ble_rscs_c;nRF5_SDK_15\components\ble\ble_services\ble_tps;nRF5_SDK_15\components\ble\common;nRF5_SDK_15\components\ble\nrf_ble_gatt;nRF5_SDK_15\components\ble\nrf_ble_qwr;nRF5_SDK_15\components\ble\peer_manager;nRF5_SDK_15\components\boards;nRF5_SDK_15\components\drivers_nrf\usbd;nRF5_SDK_15\components\libraries\atomic;nRF5_SDK_15\components\libraries\atomic_fifo;nRF5_SDK_15\components\libraries\atomic_flags;nRF5_SDK_15\components\libraries\balloc;nRF5_SDK_15\components\libraries\bootloader\ble_dfu;nRF5_SDK_15\components\libraries\bsp;nRF5_SDK_15\components\libraries\button;nRF5_SDK_15\components\libraries\cli;nRF5_SDK_15\components\libraries\crc16;nRF5_SDK_15\components\libraries\crc32;nRF5_SDK_15\components\libraries\crypto;nRF5_SDK_15\components\libraries\csense;nRF5_SDK_15\components\libraries\csense_drv;nRF5_SDK_15\components\libraries\delay;nRF5_SDK_15\components\libraries\ecc;nRF5_SDK_15\components\libraries\experimental_section_vars;nRF5_SDK_15\components\libraries\experimental_task_manager;nRF5_SDK_15\components\libraries\fds;nRF5_SDK_15\components\libraries\fstorage;nRF5_SDK_15\components\libraries\gfx;nRF5_SDK_15\components\libraries\gpiote;nRF5_SDK_15\components\libraries\hardfault;nRF5_SDK_15\components\libraries\hci;nRF5_SDK_15\components\libraries\led_softblink;nRF5_SDK_15\components\libraries\log;nRF5_SDK_15\components\libraries\log\src;nRF5_SDK_15\components\libraries\low_power_pwm;nRF5_SDK_15\components\libraries\mem_manager;nRF5_SDK_15\components\libraries\memobj;nRF5_SDK_15\components\libraries\mpu;nRF5_SDK_15\components\libraries\mutex;nRF5_SDK_15\components\libraries\pwm;nRF5_SDK_15\components\libraries\pwr_mgmt;nRF5_SDK_15\components\libraries\queue;nRF5_SDK_15\components\libraries\ringbuf;nRF5_SDK_15\components\libraries\scheduler;nRF5_SDK_15\components\libraries\sdcard;nRF5_SDK_15\components\libraries\sensorsim;nRF5_SDK_15\components\libraries\slip;nRF5_SDK_15\components\libraries\sortlist;nRF5_SDK_15\components\libraries\spi_mngr;nRF5_SDK_15\components\libraries\stack_guard;nRF5_SDK_15\components\libraries\strerror;nRF5_SDK_15\components\libraries\svc;nRF5_SDK_15\components\libraries\timer;nRF5_SDK_15\components\libraries\twi_mngr;nRF5_SDK_15\components\libraries\twi_sensor;nRF5_SDK_15\components\libraries\usbd;nRF5_SDK_15\components\libraries\usbd\class\audio;nRF5_SDK_15\components\libraries\usbd\class\cdc;nRF5_SDK_15\components\libraries\usbd\class\cdc\acm;nRF5_SDK_15\components\libraries\usbd\class\hid;nRF5_SDK_15\components\libraries\usbd\class\hid\generic;nRF5_SDK_15\components\libraries\usbd\class\hid\kbd;nRF5_SDK_15\components\libraries\usbd\class\hid\mouse;nRF5_SDK_15\components\libraries\usbd\class\msc;nRF5_SDK_15\components\libraries\util;nRF5_SDK_15\components\nfc\ndef\conn_hand_parser;nRF5_SDK_15\components\nfc\ndef\conn_hand_parser\ac_rec_parser;nRF5_SDK_15\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;nRF5_SDK_15\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;nRF5_SDK_15\components\nfc\ndef\connection_handover\ac_rec;nRF5_SDK_15\components\nfc\ndef\connection_handover\ble_oob_advdata;nRF5_SDK_15\components\nfc\ndef\connection_handover\ble_pair_lib;nRF5_SDK_15\components\nfc\ndef\connection_handover\ble_pair_msg;nRF5_SDK_15\components\nfc\ndef\connection_handover\common;nRF5_SDK_15\components\nfc\ndef\connection_handover\ep_oob_rec;nRF5_SDK_15\components\nfc\ndef\connection_handover\hs_rec;nRF5_SDK_15\components\nfc\ndef\connection_handover\le_oob_rec;nRF5_SDK_15\components\nfc\ndef\generic\message;nRF5_SDK_15\components\nfc\ndef\generic\record;nRF5_SDK_15\components\nfc\ndef\launchapp;nRF5_SDK_15\components\nfc\ndef\parser\message;nRF5_SDK_15\components\nfc\ndef\parser\record;nRF5_SDK_15\components\nfc\ndef\text;nRF5_SDK_15\components\nfc\ndef\uri;nRF5_SDK_15\components\nfc\t2t_lib;nRF5_SDK_15\components\nfc\t2t_lib\hal_t2t;nRF5_SDK_15\components\nfc\t2t_parser;nRF5_SDK_15\components\nfc\t4t_lib;nRF5_SDK_15\components\nfc\t4t_lib\hal_t4t;nRF5_SDK_15\components\nfc\t4t_parser\apdu;nRF5_SDK_15\components\nfc\t4t_parser\cc_file;nRF5_SDK_15\components\nfc\t4t_parser\hl_detection_procedure;nRF5_SDK_15\components\nfc\t4t_parser\tlv;nRF5_SDK_15\components\softdevice\common;nRF5_SDK_15\components\softdevice\s140\headers;nRF5_SDK_15\components\softdevice\s140\headers\nrf52;nRF5_SDK_15\external\fprintf;nRF5_SDK_15\external\segger_rtt;nRF5_SDK_15\external\utf_converter;nRF5_SDK_15\integration\nrfx;nRF5_SDK_15\integration\nrfx\legacy;nRF5_SDK_15\modules\nrfx;nRF5_SDK_15\modules\nrfx\drivers\include;nRF5_SDK_15\modules\nrfx\hal;nRF5_SDK_15\modules\nrfx\mdk;config;version;ble
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=6,-DS140,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: nRF5_SDK_15\components;nRF5_SDK_15\components\ble\ble_advertising;nRF5_SDK_15\components\ble\ble_dtm;nRF5_SDK_15\components\ble\ble_racp;nRF5_SDK_15\components\ble\ble_services\ble_ancs_c;nRF5_SDK_15\components\ble\ble_services\ble_ans_c;nRF5_SDK_15\components\ble\ble_services\ble_bas;nRF5_SDK_15\components\ble\ble_services\ble_bas_c;nRF5_SDK_15\components\ble\ble_services\ble_cscs;nRF5_SDK_15\components\ble\ble_services\ble_cts_c;nRF5_SDK_15\components\ble\ble_services\ble_dfu;nRF5_SDK_15\components\ble\ble_services\ble_dis;nRF5_SDK_15\components\ble\ble_services\ble_gls;nRF5_SDK_15\components\ble\ble_services\ble_hids;nRF5_SDK_15\components\ble\ble_services\ble_hrs;nRF5_SDK_15\components\ble\ble_services\ble_hrs_c;nRF5_SDK_15\components\ble\ble_services\ble_hts;nRF5_SDK_15\components\ble\ble_services\ble_ias;nRF5_SDK_15\components\ble\ble_services\ble_ias_c;nRF5_SDK_15\components\ble\ble_services\ble_lbs;nRF5_SDK_15\components\ble\ble_services\ble_lbs_c;nRF5_SDK_15\components\ble\ble_services\ble_lls;nRF5_SDK_15\components\ble\ble_services\ble_nus;nRF5_SDK_15\components\ble\ble_services\ble_nus_c;nRF5_SDK_15\components\ble\ble_services\ble_rscs;nRF5_SDK_15\components\ble\ble_services\ble_rscs_c;nRF5_SDK_15\components\ble\ble_services\ble_tps;nRF5_SDK_15\components\ble\common;nRF5_SDK_15\components\ble\nrf_ble_gatt;nRF5_SDK_15\components\ble\nrf_ble_qwr;nRF5_SDK_15\components\ble\peer_manager;nRF5_SDK_15\components\boards;nRF5_SDK_15\components\drivers_nrf\usbd;nRF5_SDK_15\components\libraries\atomic;nRF5_SDK_15\components\libraries\atomic_fifo;nRF5_SDK_15\components\libraries\atomic_flags;nRF5_SDK_15\components\libraries\balloc;nRF5_SDK_15\components\libraries\bootloader\ble_dfu;nRF5_SDK_15\components\libraries\bsp;nRF5_SDK_15\components\libraries\button;nRF5_SDK_15\components\libraries\cli;nRF5_SDK_15\components\libraries\crc16;nRF5_SDK_15\components\libraries\crc32;nRF5_SDK_15\components\libraries\crypto;nRF5_SDK_15\components\libraries\csense;nRF5_SDK_15\components\libraries\csense_drv;nRF5_SDK_15\components\libraries\delay;nRF5_SDK_15\components\libraries\ecc;nRF5_SDK_15\components\libraries\experimental_section_vars;nRF5_SDK_15\components\libraries\experimental_task_manager;nRF5_SDK_15\components\libraries\fds;nRF5_SDK_15\components\libraries\fstorage;nRF5_SDK_15\components\libraries\gfx;nRF5_SDK_15\components\libraries\gpiote;nRF5_SDK_15\components\libraries\hardfault;nRF5_SDK_15\components\libraries\hci;nRF5_SDK_15\components\libraries\led_softblink;nRF5_SDK_15\components\libraries\log;nRF5_SDK_15\components\libraries\log\src;nRF5_SDK_15\components\libraries\low_power_pwm;nRF5_SDK_15\components\libraries\mem_manager;nRF5_SDK_15\components\libraries\memobj;nRF5_SDK_15\components\libraries\mpu;nRF5_SDK_15\components\libraries\mutex;nRF5_SDK_15\components\libraries\pwm;nRF5_SDK_15\components\libraries\pwr_mgmt;nRF5_SDK_15\components\libraries\queue;nRF5_SDK_15\components\libraries\ringbuf;nRF5_SDK_15\components\libraries\scheduler;nRF5_SDK_15\components\libraries\sdcard;nRF5_SDK_15\components\libraries\sensorsim;nRF5_SDK_15\components\libraries\slip;nRF5_SDK_15\components\libraries\sortlist;nRF5_SDK_15\components\libraries\spi_mngr;nRF5_SDK_15\components\libraries\stack_guard;nRF5_SDK_15\components\libraries\strerror;nRF5_SDK_15\components\libraries\svc;nRF5_SDK_15\components\libraries\timer;nRF5_SDK_15\components\libraries\twi_mngr;nRF5_SDK_15\components\libraries\twi_sensor;nRF5_SDK_15\components\libraries\usbd;nRF5_SDK_15\components\libraries\usbd\class\audio;nRF5_SDK_15\components\libraries\usbd\class\cdc;nRF5_SDK_15\components\libraries\usbd\class\cdc\acm;nRF5_SDK_15\components\libraries\usbd\class\hid;nRF5_SDK_15\components\libraries\usbd\class\hid\generic;nRF5_SDK_15\components\libraries\usbd\class\hid\kbd;nRF5_SDK_15\components\libraries\usbd\class\hid\mouse;nRF5_SDK_15\components\libraries\usbd\class\msc;nRF5_SDK_15\components\libraries\util;nRF5_SDK_15\components\nfc\ndef\conn_hand_parser;nRF5_SDK_15\components\nfc\ndef\conn_hand_parser\ac_rec_parser;nRF5_SDK_15\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;nRF5_SDK_15\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;nRF5_SDK_15\components\nfc\ndef\connection_handover\ac_rec;nRF5_SDK_15\components\nfc\ndef\connection_handover\ble_oob_advdata;nRF5_SDK_15\components\nfc\ndef\connection_handover\ble_pair_lib;nRF5_SDK_15\components\nfc\ndef\connection_handover\ble_pair_msg;nRF5_SDK_15\components\nfc\ndef\connection_handover\common;nRF5_SDK_15\components\nfc\ndef\connection_handover\ep_oob_rec;nRF5_SDK_15\components\nfc\ndef\connection_handover\hs_rec;nRF5_SDK_15\components\nfc\ndef\connection_handover\le_oob_rec;nRF5_SDK_15\components\nfc\ndef\generic\message;nRF5_SDK_15\components\nfc\ndef\generic\record;nRF5_SDK_15\components\nfc\ndef\launchapp;nRF5_SDK_15\components\nfc\ndef\parser\message;nRF5_SDK_15\components\nfc\ndef\parser\record;nRF5_SDK_15\components\nfc\ndef\text;nRF5_SDK_15\components\nfc\ndef\uri;nRF5_SDK_15\components\nfc\t2t_lib;nRF5_SDK_15\components\nfc\t2t_lib\hal_t2t;nRF5_SDK_15\components\nfc\t2t_parser;nRF5_SDK_15\components\nfc\t4t_lib;nRF5_SDK_15\components\nfc\t4t_lib\hal_t4t;nRF5_SDK_15\components\nfc\t4t_parser\apdu;nRF5_SDK_15\components\nfc\t4t_parser\cc_file;nRF5_SDK_15\components\nfc\t4t_parser\hl_detection_procedure;nRF5_SDK_15\components\nfc\t4t_parser\tlv;nRF5_SDK_15\components\softdevice\common;nRF5_SDK_15\components\softdevice\s140\headers;nRF5_SDK_15\components\softdevice\s140\headers\nrf52;nRF5_SDK_15\external\fprintf;nRF5_SDK_15\external\segger_rtt;nRF5_SDK_15\external\utf_converter;nRF5_SDK_15\integration\nrfx;nRF5_SDK_15\integration\nrfx\legacy;nRF5_SDK_15\modules\nrfx;nRF5_SDK_15\modules\nrfx\drivers\include;nRF5_SDK_15\modules\nrfx\hal;nRF5_SDK_15\modules\nrfx\mdk;config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xda000
  memory RVCT9: RAM 0x20002210 size 0x3ddf0
  link misc: --diag_suppress 6330
  group Application
    ./: main.c
    config/: sdk_config.h
    version/: version.c
  group Board Definition
    nRF5_SDK_15/components/boards/: boards.c
  group Board Support
    nRF5_SDK_15/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group UTF8/UTF16 converter
    nRF5_SDK_15/external/utf_converter/: utf.c
  group nRF_BLE
    nRF5_SDK_15/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    nRF5_SDK_15/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    nRF5_SDK_15/components/ble/ble_advertising/: ble_advertising.c
    nRF5_SDK_15/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    nRF5_SDK_15/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_Drivers
    nRF5_SDK_15/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    nRF5_SDK_15/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_uart.c nrfx_uarte.c
    nRF5_SDK_15/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    nRF5_SDK_15/components/libraries/button/: app_button.c
    nRF5_SDK_15/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    nRF5_SDK_15/components/libraries/scheduler/: app_scheduler.c
    nRF5_SDK_15/components/libraries/timer/: app_timer.c
    nRF5_SDK_15/components/libraries/crc16/: crc16.c
    nRF5_SDK_15/components/libraries/fds/: fds.c
    nRF5_SDK_15/components/libraries/hardfault/: hardfault_implementation.c
    nRF5_SDK_15/components/libraries/atomic_fifo/: nrf_atfifo.c
    nRF5_SDK_15/components/libraries/atomic_flags/: nrf_atflags.c
    nRF5_SDK_15/components/libraries/atomic/: nrf_atomic.c
    nRF5_SDK_15/components/libraries/balloc/: nrf_balloc.c
    nRF5_SDK_15/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    nRF5_SDK_15/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    nRF5_SDK_15/components/libraries/memobj/: nrf_memobj.c
    nRF5_SDK_15/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    nRF5_SDK_15/components/libraries/ringbuf/: nrf_ringbuf.c
    nRF5_SDK_15/components/libraries/experimental_section_vars/: nrf_section_iter.c
    nRF5_SDK_15/components/libraries/strerror/: nrf_strerror.c
    nRF5_SDK_15/components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    nRF5_SDK_15/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    nRF5_SDK_15/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    nRF5_SDK_15/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group Application - BLE
    ble/: app_ble.c
target flash_s140_nrf52_6.1.0_softdevice (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: as above
  output: s140_nrf52_6.1.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xda000
  memory RVCT9: RAM 0x20002210 size 0x3ddf0
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.1.2, Device:Startup 8.17.0
